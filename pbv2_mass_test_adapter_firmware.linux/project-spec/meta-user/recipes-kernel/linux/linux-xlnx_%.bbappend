SRC_URI += "file://user_2019-07-17-14-00-00.cfg \
            file://user_2019-07-23-15-27-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

